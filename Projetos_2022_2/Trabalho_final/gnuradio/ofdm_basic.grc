options:
  parameters:
    author: survivor
    generate_options: qt_gui
    id: ofdm_basic
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Excess_BW_var
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: QAM_constellation
  id: variable_constellation
  parameters:
    const_points: '[(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]'
    precision: '8'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    type: 16qam
  states: {}
- name: QPSK
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab@0
    start: '0'
    step: '0.2'
    stop: '10'
    value: '1'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Sending a complete byte
    max: '256'
    min: '0'
    num_samps: '500'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK
    differential: 'True'
    excess_bw: Excess_BW_var
    samples_per_symbol: samp_per_sym
    verbose: 'True'
  states: {state: disabled}
- name: digital_ofdm_carrier_allocator_cvc_1
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    output_is_shifted: 'True'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    sync_words: ((),)
  states: {state: disabled}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len/4
    input_size: fft_len
    tagname: '"frame_len"'
  states: {state: disabled}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"QPSK"'
    packet_len_key: length
    payload_mod: '"QPSK"'
    rolloff: '0'
  states: {state: disabled}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '1'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: qtgui_tab@0
    name: '"Constelação 16 QAM"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab@1
    type: complex
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    label0: Constellation
    label1: Frequency
    label2: Tab 2
    label3: Tab 3
    label4: Tab 4
    num_tabs: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', digital_psk_mod_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_carrier_allocator_cvc_1, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', qtgui_time_sink_x_0, '0']
- [digital_psk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
